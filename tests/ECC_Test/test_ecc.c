#include "uECC.h"
#include <stdio.h>
#include "pubkey.h"

 static const uint8_t digest[32] = {
        0xee,0xad,0x59,0x8d,0xa5,0x43,0x75,0xf5,0x3a,0xa9,0xd3,0x2d,0x43,0x45,0xdc,0xc0,
        0x8a,0x56,0xd5,0x72,0x72,0x83,0xb4,0x6f,0xa5,0x44,0x0a,0xe0,0xa7,0xde,0x34,0x44,
    };

    static const uint8_t sig[64] = {
        0x0b,0xc0,0x98,0xe3,0x11,0xeb,0xbe,0xa4,0xed,0xe7,0x15,0xcf,0xf0,0x56,0x0c,0x4e,
        0x2d,0x69,0x3b,0x22,0x41,0x47,0xe3,0xdf,0x9c,0x79,0x8f,0xa9,0xb5,0x00,0x5f,0x43,
        0xd6,0x92,0x6b,0xa4,0x4d,0x30,0x04,0x87,0x86,0x0b,0x40,0xf3,0xc2,0x14,0x69,0x26,
        0xfe,0x5d,0xe4,0x2d,0xae,0xf6,0xd9,0xad,0x62,0xbb,0x64,0x4e,0x2e,0xb9,0x67,0x6d,
    };

int TEST_ECC()
{
    int r = uECC_verify(g_pubkey, digest, 32, sig, uECC_secp256r1());
    if (r) {
        printf("\033[1;32m");
        printf("**SIGNATURE VERIFIED!**\n");
        printf("\033[0m");
    } else {
        printf("\033[1;31m");
        printf("**SIGNATURE VERIFICATION FAILED!**\n");
        printf("\033[0m");
    }
    return r;
}

int TEST_ECC_TAMPERED_DIGEST()
{
    static const uint8_t tampered_digest[32] = {
        0x00 /*Tampered*/,0xad,0x59,0x8d,0xa5,0x43,0x75,0xf5,0x3a,0xa9,0xd3,0x2d,0x43,0x45,0xdc,0xc0,
        0x8a,0x56,0xd5,0x72,0x72,0x83,0xb4,0x6f,0xa5,0x44,0x0a,0xe0,0xa7,0xde,0x34,0x44,
    };

    int r = uECC_verify(g_pubkey, tampered_digest, 32, sig, uECC_secp256r1());
    if (r) {
        printf("\033[1;31m");
        printf("**SIGNATURE VERIFICATION SHOULD HAVE FAILED BUT DID NOT!**\n");
        printf("\033[0m");
    } else {
        printf("\033[1;32m");
        printf("**SIGNATURE VERIFICATION FAILED AS EXPECTED!**\n");
        printf("\033[0m");
    }
    return !r;
}

int TEST_ECC_ATTACKER_KEY()
{
    static const uint8_t attacker_pubkey[64] = {
    0xa8, 0x30, 0x73, 0x8e, 0xe4, 0x25, 0x11, 0xcc, 0x70, 0x77, 0x53, 0x7f, 0xd6, 0x5f, 0xaa, 0xd8, 
    0x4c, 0x90, 0x63, 0x8b, 0x41, 0xa1, 0x28, 0x31, 0x99, 0x65, 0x90, 0x9d, 0x44, 0x43, 0x45, 0x8c, 
    0x8b, 0xbf, 0x09, 0x5f, 0x2f, 0x87, 0x8f, 0x53, 0x75, 0xe8, 0x73, 0x75, 0x6f, 0x53, 0x71, 0x98, 
    0xdb, 0xc3, 0x46, 0xf7, 0xe1, 0x4a, 0x90, 0xe3, 0x9b, 0xd3, 0x50, 0xbc, 0xe3, 0x82, 0x54, 0x59
    };

    int r = uECC_verify(attacker_pubkey, digest, 32, sig, uECC_secp256r1());
    if (r) {
        printf("\033[1;31m");
        printf("**SIGNATURE VERIFICATION SHOULD HAVE FAILED BUT DID NOT!**\n");
        printf("\033[0m");
    } else {
        printf("\033[1;32m");
        printf("**SIGNATURE VERIFICATION FAILED AS EXPECTED!**\n");
        printf("\033[0m");
    }

    return !r;
}

int main()
{
    int result = 1;
    result &= TEST_ECC();
    result &= TEST_ECC_TAMPERED_DIGEST();
    result &= TEST_ECC_ATTACKER_KEY();
    printf("\n\n");
    
    return result ? 0 : 1;
}